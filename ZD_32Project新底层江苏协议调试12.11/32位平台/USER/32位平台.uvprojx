# Keil uVision project 32位平台.uvprojx, settings and files
target 32 位平台测试 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 32_BIT +hex
  AfterMake: fromelf --bin !L --output  ..\Output\APP.bin
  AfterMake: ..\Resource\post.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL,Hardware_Version_V131
  c misc: --locale=english
  c include: ..\CMSIS;..\FWlib\inc;..\APP;..\BSP\Include;..\uCOS-II\Ports;..\uCOS-II\Source;..\MAIN;..\INTERRUPT-MANAGE\Include;..\GUI\Include;..\Source\interface\inc;..\..\GSFLibraries\STM32F10x_GSFGLibC\inc;..\..\Utilities\Utilities;..\Service_Layer\Include;..\DataLink_Layer\Include;..\Driver_Layer\Include;..\Physical_Layer\Include;..\C_Http\Inc;..\BSP\Com_Protocol\Include;..\BSP\Gateway-NJSY\Include;..\BSP\Gateway-HZZH\Include;..\BSP\MCU_Peripheral\Include;..\BSP\GSM
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7d000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_fsmc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group uCOS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group INTERRUPT_MANAGE
    ../INTERRUPT-MANAGE/Source/: stm32f10x_it.c
  group BSP
    ../BSP/Source/: App_GPS.c App_Print.c App_Save.c BSP.c Dev_Flash.c Dev_Fram.c Dev_Gps.c Dev_Oled.c Dev_RTC.c FONT.c Log_Alarm.c Log_ADC1.c Log_Battery.c Log_ConfigService.c Log_ConfigService_Http.c Log_COM.c Log_CRC16.c Log_Download.c Log_Flash.c Log_GPS.c Log_GSM.c Log_HTTP.c Log_Hum_Cal.c Log_IAP.c Log_INF.c Log_MD5.c Log_Power.c Log_Print.c Log_RF_Card.c Log_Save.c Log_Sensor.c Log_SMS.c Log_Temp_Cal.c Log_Temp_PT1000.c Log_Time.c Mcu_ADC.c Mcu_Beep.c Mcu_Button.c Mcu_Config.c Mcu_DMA.c Mcu_DMA2.c Mcu_Flash.c Mcu_Fram.c Mcu_GPS.c Mcu_led.c Mcu_Oled.c Mcu_Power.c Mcu_RTC.c Mcu_SPI.c Mcu_Uart4.c Mcu_Usart.c dev_i2c.cpp app_gsm.cpp dev_gsm.cpp Log_WatchDog.c Log_GSM_Config.c
  group APP
    ../APP/: app.c
  group Com_Protocol
    ../BSP/Com_Protocol/Source/: ComProtocol_GY.c ComProtocol_SetPlateNo.c ComProtocol_WZ.c ComProtocol_ZDE.c
  group 江苏省免疫局接口协议
    ../BSP/Com_Protocol/Source/: ComProtocol_JS.c
  group DataLink_Layer
    ../DataLink_Layer/Source/: DataLink_Cfg_Tab.C Data_Link_Fix_Cfg_Tab.C
  group Driver_Layer
    ../Driver_Layer/Source/: Dev_AI2C.C
  group MAIN
    ../MAIN/: Main.c
  group MCU_Peripheral
    ../BSP/MCU_Peripheral/Source/: Mcu_DMA1.c Mcu_Usart2.c
  group Gateway-HZZH
    ../BSP/Gateway-HZZH/Source/: Dev_Gateway_HZZH.c Log_Gateway_HZZH.c App_Gateway_HZZH.c
  group Gateway-NJSY
    ../BSP/Gateway-NJSY/Source/: Log_Gateway_NJSY.c Dev_Gateway_NJSY.c App_Gateway_NJSY.c
  group GUI
    ../GUI/Source/: Ks0108.C Menu.C MenuAlarmDelay.C MenuAlarmSaveInterval.C MenuAlarmSet.C MenuChannelThreshold.c MenuClearHistoricData.C MenuCutPowerSMSAlarmSet.c MenuCutPowerSoundLightAlarmSet.c MenuDesktop.C MenuDesktopStartRecord.C MenuDesktopStopRecord.C MenuFirmwareUrerade.C MenuFSM.C MenuGsmDebug.C MenuGW.C MenuGWActiveTime.C MenuGWAdder.C MenuGWChannel.C MenuGWMode.C MenuGWWorkState.C MenuGWHZZH.C MenuGWHZZHWorkState.C MenuGWHZZHWkupTime.C MenuICO.C MenuInstruID.C MenuLowPowerSMSAlarmSet.C MenuLowPowerSoundLightAlarmSet.C MenuNetworkParaIndex.C MenuNormalSaveInterval.C MenuPrintData.C MenuPrintEndTimeSet.C MenuPrintSet.C MenuPrintStartTimeSet.C MenuPrintTimeIntervalSetIndex.C MenuRestoreFactorySet.C MenuRunPara.C MenuSenLowLitSet.C MenuSenUpLitSet.C MenuSenUpLowlitSec.C MenuSMSAlarm.C MenuSMSAlarmChannelSelect.C MenuSMSAlarmMasterSwitchSet.C MenuSMSAlarmPhoneNO.C MenuSMSAlarmPhoneNOSet.C MenuSMSAlarmRepeatInterval.C MenuSMSAlarmSet.C MenuSoundLightAlarm.C MenuSoundLightAlarmChannelSelect.C MenuSoundLightAlarmMasterSwitchSet.C MenuSoundLightAlarmSet.C MenuSystemClock.C MenuSystemLanguage.C MenuSystemSet.C MenuSystemVersion.C MenuUploadNetworkAdderIndex.C MenuWifiParameter.C MenuUserPermSet.C
  group GSFLIB
    ../../GSFLibraries/STM32F10x_GSFGLibC/lib/: STM3210E-LIB.lib
  group Physical_Layer
    ../Physical_Layer/Source/: Psl_AI2C.C
  group Service_Layer
    ../Service_Layer/Source/: Sve_Cfg_Tab.C Sve_Fix_Cfg_Tab.C
  group GSM
    ../BSP/GSM/: GSM.c Gsm_Api.c GSM_App.c GSM_esp8266.c GSM_USART.C String_Utility.c GSM_MG2639.c
  group Read Me
    ./: 程序版本说明.txt 开发过程记录.txt
  group Program Update（QNZ）
    ../Program Update（QNZ）/: 程序更新说明.txt
